# IAR project Prj_Murata_L462.ewp, settings and files
configuration DiscoL462_T1SC (ARM, debug)
  General.OGChipSelectEditMenu: STM32L462RE ST STM32L462RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; DISCO_L462; APPLICATION_CONFIG_FILE="plf_cellular_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_cellular_app_thread_config.h"
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STM32_Cellular\Config; ..\STM32_Cellular\Target; ..\..\..\..\Misc\Cmd\Inc; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc; ..\..\..\..\Misc\Samples\Cellular\Inc; ..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc; ..\STM32_Cellular\Config; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc
  OBJCOPY.OOCOutputFile: DiscoL462_T1SC.bin
  ILINK.IlinkOutputFile: DiscoL462_T1SC.out
  ILINK.IlinkIcfFile: stm32l462xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DiscoL462_T1SC_LwIP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; DISCO_L462; APPLICATION_CONFIG_FILE="plf_cellular_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_cellular_app_thread_config.h"; USE_LOW_POWER=0
  OBJCOPY.OOCOutputFile: DiscoL462_T1SC_LwIP.bin
  ILINK.IlinkOutputFile: DiscoL462_T1SC_LwIP.out
configuration DiscoL462_T1SC_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; SW_DEBUG_VERSION=0; DISCO_L462; APPLICATION_CONFIG_FILE="plf_cellular_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_cellular_app_thread_config.h"
  OBJCOPY.OOCOutputFile: DiscoL462_T1SC_Rel.bin
  ILINK.IlinkOutputFile: DiscoL462_T1SC_Rel.out
configuration DiscoL462_T1SC_LwIP_Rel (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L462xx; USE_STM32L462E_CELL01; USE_SOCKETS_TYPE=USE_SOCKETS_LWIP; SW_DEBUG_VERSION=0; DISCO_L462; APPLICATION_CONFIG_FILE="plf_cellular_app_config.h"; APPLICATION_THREAD_CONFIG_FILE="plf_cellular_app_thread_config.h"; USE_LOW_POWER=0
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STM32_Cellular\Config; ..\STM32_Cellular\Target; ..\..\..\..\Misc\Cmd\Inc; ..\..\..\..\Misc\Ndlc\Core\Inc; ..\..\..\..\Misc\Ndlc\Interface\Inc; ..\..\..\..\Misc\RTOS\FreeRTOS\Inc; ..\..\..\..\Misc\Samples\Cellular\Inc; ..\..\..\..\Misc\SPI\Inc; ..\..\..\..\..\Drivers\BSP\X_STMOD_PLUS_MODEMS\TYPE1SC\AT_modem_type1sc\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\AT_Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Cellular_Service\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Data_Cache\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Error\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Ipc\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\PPPosif\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Runtime_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Rtosal\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Core\Trace\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Cellular_Ctrl\Inc; ..\..\..\..\..\Middlewares\ST\STM32_Cellular\Interface\Com\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\lwip\prot; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\netif\ppp; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system
  OBJCOPY.OOCOutputFile: DiscoL462_T1SC_LwIP_Rel.bin
  ILINK.IlinkOutputFile: DiscoL462_T1SC_LwIP_Rel.out
configuration Jenkins_Config (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32l462xx.s
  group Application/User
    ../Core/Src/: gpio.c i2c.c main.c quadspi.c rng.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c tim.c usart.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC
    ../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Src/: at_custom_modem_api.c at_custom_modem_sid.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c at_custom_sysctrl.c
    ../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/TYPE1SC/AT_modem_type1sc/Inc/: plf_modem_config.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_socket.c at_parser.c at_signalling_analyze.c at_signalling_build.c at_sysctrl.c at_util.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_datacache.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_socket.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/Cellular/Core/Data_Cache
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Core/Error
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../STM32_Cellular/Target/: board_interrupts.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/PPPosif
    ../../../../../Middlewares/ST/STM32_Cellular/Core/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c com_utils.c
  group Middlewares/Cellular/Interface/Control
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/LwIP/api
    ../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/core
    ../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/core/ipv4
    ../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/netif/ppp
    ../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
  group Middlewares/Third_Party/LwIP/system/OS
    ../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Misc/Cmd
    ../../../../Misc/Cmd/Src/: cmd.c
  group Misc/FreeRTOS
    ../../../../Misc/RTOS/FreeRTOS/Src/: freertos.c
  group Misc/Samples/Cellular
    ../../../../Misc/Samples/Cellular/Src/: cellular_app.c cellular_app_cmd.c cellular_app_datetime.c cellular_app_echoclient.c cellular_app_pingclient.c cellular_app_socket.c
    ../../../../Misc/Samples/Cellular/Inc/: plf_cellular_app_config.h plf_cellular_app_thread_config.h
  group plf_config
    ../STM32_Cellular/Config/: plf_config.h plf_features.h plf_hw_config.h plf_ipc_config.h plf_power_config.h plf_rtosal_config.h plf_sw_config.h plf_thread_config.h
