<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NBIOT_L4S5I_Azure.ewp</path>
  </project>
  <batchBuild />
</workspace>
