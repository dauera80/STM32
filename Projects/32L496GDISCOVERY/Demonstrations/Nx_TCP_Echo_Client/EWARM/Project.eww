<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DiscoL496_Azure.ewp</path>
  </project>
  <batchBuild />
</workspace>
