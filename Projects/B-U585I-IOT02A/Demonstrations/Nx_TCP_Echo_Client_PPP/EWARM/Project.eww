<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\B-U585I_Azure.ewp</path>
  </project>
  <batchBuild />
</workspace>
