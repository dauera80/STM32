# Keil uVision project B-U585I_Azure.uvprojx, settings and files
target U585I_BG96_TCP_Echo_Client (6140001::V6.14.1::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: U585I_BG96_TCP_Echo_Client +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx,HWREF_B_CELL_BG96_V2,TX_INCLUDE_USER_DEFINE_FILE,NX_INCLUDE_USER_DEFINE_FILE,SAMPLE_MAX_EXPONENTIAL_BACKOFF_IN_SEC=10,TX_SINGLE_MODE_NON_SECURE=1
  c misc: -Wno-format
  c include: ../Core/Inc;../STM32_Cellular/Config;../STM32_Cellular/Target;../../../../Misc/Cmd/Inc;../../../../Misc/Samples/NetXDuo/Nx_TCP_Echo_Client/Inc;../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96/AT_modem_bg96/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/CMSIS/RTOS2/Template;../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Inc;../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Inc;../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Inc;../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Inc;../../../../../Middlewares/ST/threadx/common/inc;../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../../../../../Middlewares/ST/netxduo/ports/cortex_m33/ac5/inc;../../../../../Middlewares/ST/netxduo/common/inc;../../../../../Middlewares/ST/netxduo/addons/dhcp;../../../../../Middlewares/ST/netxduo/addons/dns;../../../../../Middlewares/ST/netxduo/addons/sntp
  asm define: TX_SINGLE_MODE_NON_SECURE=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/Nx_TCP_Echo_Client
    ../../../../Misc/Samples/NetXDuo/Nx_TCP_Echo_Client/Src/: app_azure_rtos.c app_netxduo.c app_threadx.c tcp_echo_client.c
  group Application/User/Core
    ../STM32_Cellular/Target/: board_setup.c
    ../Core/Src/: gpio.c main.c rng.c rtc.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c tx_initialize_low_level.s usart.c
  group Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96
    ../../../../../Drivers/BSP/X_STMOD_PLUS_MODEMS/BG96/AT_modem_bg96/Src/: at_custom_modem_api.c at_custom_modem_sid.c at_custom_modem_signalling.c at_custom_modem_socket.c at_custom_modem_specific.c at_custom_sysctrl.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/Cellular/Core/AT_Core
    ../../../../../Middlewares/ST/STM32_Cellular/Core/AT_Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_socket.c at_parser.c at_signalling_analyze.c at_signalling_build.c at_sysctrl.c at_util.c
  group Middlewares/Cellular/Core/Cellular_Service
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Src/: cellular_service.c cellular_service_cmd.c cellular_service_config.c cellular_service_datacache.c cellular_service_int.c cellular_service_os.c cellular_service_power.c cellular_service_socket.c cellular_service_task.c cellular_service_utils.c
  group Middlewares/Cellular/Core/Data_Cache
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Data_Cache/Src/: dc_common.c
  group Middlewares/Cellular/Core/Error
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Error/Src/: error_handler.c
  group Middlewares/Cellular/Core/HW_Specific
    ../STM32_Cellular/Target/: board_interrupts.c
  group Middlewares/Cellular/Core/Ipc
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Ipc/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/Cellular/Core/Rtosal
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Rtosal/Src/: rtosal.c
  group Middlewares/Cellular/Core/Runtime_Library
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Runtime_Library/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
  group Middlewares/Cellular/Core/Trace
    ../../../../../Middlewares/ST/STM32_Cellular/Core/Trace/Src/: trace_interface.c
  group Middlewares/Cellular/Interface/Com
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Com/Src/: com_core.c com_icc.c com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c com_sockets_statistic.c
  group Middlewares/Cellular/Interface/Control
    ../../../../../Middlewares/ST/STM32_Cellular/Interface/Cellular_Ctrl/Src/: cellular_control_api.c
  group Middlewares/cmsis_rtos_threadx
    ../../../../../Middlewares/ST/cmsis_rtos_threadx/: cmsis_os2.c
  group Middlewares/Interfaces/Network/Cellular
    ../../../../../Middlewares/ST/netxduo/common/drivers/cellular/: nx_driver_stm32_cellular.c
  group Middlewares/NetXDuo/addons/dhcp
    ../../../../../Middlewares/ST/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_server.c nxd_dhcpv6_client.c nxd_dhcpv6_server.c
  group Middlewares/NetXDuo/addons/dns
    ../../../../../Middlewares/ST/netxduo/addons/dns/: nxd_dns.c
  group Middlewares/NetXDuo/addons/sntp
    ../../../../../Middlewares/ST/netxduo/addons/sntp/: nxd_sntp_client.c
  group Middlewares/NetXDuo/common/src
    ../../../../../Middlewares/ST/netxduo/common/src/: nx_arp_announce_send.c nx_arp_dynamic_entries_invalidate.c nx_arp_dynamic_entry_delete.c nx_arp_dynamic_entry_set.c nx_arp_enable.c nx_arp_entry_allocate.c nx_arp_entry_delete.c nx_arp_gratuitous_send.c nx_arp_hardware_address_find.c nx_arp_info_get.c nx_arp_initialize.c nx_arp_interface_entries_delete.c nx_arp_ip_address_find.c nx_arp_packet_deferred_receive.c nx_arp_packet_receive.c nx_arp_packet_send.c nx_arp_periodic_update.c nx_arp_probe_send.c nx_arp_queue_process.c nx_arp_queue_send.c nx_arp_static_entries_delete.c nx_arp_static_entry_create.c nx_arp_static_entry_delete.c nx_arp_static_entry_delete_internal.c nx_icmp_cleanup.c nx_icmp_enable.c nx_icmp_info_get.c nx_icmp_interface_ping.c nx_icmp_interface_ping6.c nx_icmp_packet_process.c nx_icmp_packet_receive.c nx_icmp_ping.c nx_icmp_ping6.c nx_icmp_queue_process.c nx_icmpv4_packet_process.c nx_icmpv4_process_echo_reply.c nx_icmpv4_process_echo_request.c nx_icmpv4_send_error_message.c nx_icmpv6_DAD_clear_NDCache_entry.c nx_icmpv6_DAD_failure.c nx_icmpv6_dest_table_add.c nx_icmpv6_dest_table_find.c nx_icmpv6_destination_table_periodic_update.c nx_icmpv6_packet_process.c nx_icmpv6_perform_DAD.c nx_icmpv6_process_echo_reply.c nx_icmpv6_process_echo_request.c nx_icmpv6_process_na.c nx_icmpv6_process_ns.c nx_icmpv6_process_packet_too_big.c nx_icmpv6_process_ra.c nx_icmpv6_process_redirect.c nx_icmpv6_send_error_message.c nx_icmpv6_send_ns.c nx_icmpv6_send_queued_packets.c nx_icmpv6_send_rs.c nx_icmpv6_validate_neighbor_message.c nx_icmpv6_validate_options.c nx_icmpv6_validate_ra.c nx_igmp_enable.c nx_igmp_info_get.c nx_igmp_interface_report_send.c nx_igmp_loopback_disable.c nx_igmp_loopback_enable.c nx_igmp_multicast_check.c nx_igmp_multicast_interface_join.c nx_igmp_multicast_interface_join_internal.c nx_igmp_multicast_interface_leave.c nx_igmp_multicast_interface_leave_internal.c nx_igmp_multicast_join.c nx_igmp_multicast_leave.c nx_igmp_packet_process.c nx_igmp_packet_receive.c nx_igmp_periodic_processing.c nx_igmp_queue_process.c nx_invalidate_destination_entry.c nx_ip_address_change_notify.c nx_ip_address_get.c nx_ip_address_set.c nx_ip_auxiliary_packet_pool_set.c nx_ip_checksum_compute.c nx_ip_create.c nx_ip_deferred_link_status_process.c nx_ip_delete.c nx_ip_delete_queue_clear.c nx_ip_dispatch_process.c nx_ip_driver_deferred_enable.c nx_ip_driver_deferred_processing.c nx_ip_driver_deferred_receive.c nx_ip_driver_direct_command.c nx_ip_driver_interface_direct_command.c nx_ip_driver_link_status_event.c nx_ip_driver_packet_send.c nx_ip_fast_periodic_timer_entry.c nx_ip_forward_packet_process.c nx_ip_forwarding_disable.c nx_ip_forwarding_enable.c nx_ip_fragment_assembly.c nx_ip_fragment_disable.c nx_ip_fragment_enable.c nx_ip_fragment_forward_packet.c nx_ip_fragment_packet.c nx_ip_fragment_timeout_check.c nx_ip_gateway_address_clear.c nx_ip_gateway_address_get.c nx_ip_gateway_address_set.c nx_ip_header_add.c nx_ip_info_get.c nx_ip_initialize.c nx_ip_interface_address_get.c nx_ip_interface_address_mapping_configure.c nx_ip_interface_address_set.c nx_ip_interface_attach.c nx_ip_interface_capability_get.c nx_ip_interface_capability_set.c nx_ip_interface_detach.c nx_ip_interface_info_get.c nx_ip_interface_mtu_set.c nx_ip_interface_physical_address_get.c nx_ip_interface_physical_address_set.c nx_ip_interface_status_check.c nx_ip_link_status_change_notify_set.c nx_ip_max_payload_size_find.c nx_ip_packet_checksum_compute.c nx_ip_packet_deferred_receive.c nx_ip_packet_receive.c nx_ip_packet_send.c nx_ip_periodic_timer_entry.c nx_ip_raw_packet_cleanup.c nx_ip_raw_packet_disable.c nx_ip_raw_packet_enable.c nx_ip_raw_packet_filter_set.c nx_ip_raw_packet_processing.c nx_ip_raw_packet_receive.c nx_ip_raw_packet_send.c nx_ip_raw_packet_source_send.c nx_ip_raw_receive_queue_max_set.c nx_ip_route_find.c nx_ip_static_route_add.c nx_ip_static_route_delete.c nx_ip_status_check.c nx_ip_thread_entry.c nx_ipv4_multicast_interface_join.c nx_ipv4_multicast_interface_leave.c nx_ipv4_option_process.c nx_ipv4_packet_receive.c nx_ipv6_fragment_process.c nx_ipv6_header_add.c nx_ipv6_multicast_join.c nx_ipv6_multicast_leave.c nx_ipv6_option_error.c nx_ipv6_packet_copy.c nx_ipv6_packet_receive.c nx_ipv6_packet_send.c nx_ipv6_prefix_list_add_entry.c nx_ipv6_prefix_list_delete.c nx_ipv6_prefix_list_delete_entry.c nx_ipv6_process_fragment_option.c nx_ipv6_process_hop_by_hop_option.c nx_ipv6_process_routing_option.c nx_ipv6_util.c nx_md5.c nx_nd_cache_add.c nx_nd_cache_add_entry.c nx_nd_cache_delete_internal.c nx_nd_cache_fast_periodic_update.c nx_nd_cache_find_entry.c nx_nd_cache_find_entry_by_mac_addr.c nx_nd_cache_interface_entries_delete.c nx_nd_cache_slow_periodic_update.c nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_ram_network_driver.c nx_rarp_disable.c nx_rarp_enable.c nx_rarp_info_get.c nx_rarp_packet_deferred_receive.c nx_rarp_packet_receive.c nx_rarp_packet_send.c nx_rarp_periodic_update.c nx_rarp_queue_process.c nx_system_initialize.c nx_tcp_cleanup_deferred.c nx_tcp_client_bind_cleanup.c nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_port_get.c nx_tcp_client_socket_unbind.c nx_tcp_connect_cleanup.c nx_tcp_deferred_cleanup_check.c nx_tcp_disconnect_cleanup.c nx_tcp_enable.c nx_tcp_fast_periodic_processing.c nx_tcp_free_port_find.c nx_tcp_info_get.c nx_tcp_initialize.c nx_tcp_mss_option_get.c nx_tcp_no_connection_reset.c nx_tcp_packet_process.c nx_tcp_packet_receive.c nx_tcp_packet_send_ack.c nx_tcp_packet_send_control.c nx_tcp_packet_send_fin.c nx_tcp_packet_send_probe.c nx_tcp_packet_send_rst.c nx_tcp_packet_send_syn.c nx_tcp_periodic_processing.c nx_tcp_queue_process.c nx_tcp_receive_cleanup.c nx_tcp_server_socket_accept.c nx_tcp_server_socket_driver_listen.c nx_tcp_server_socket_listen.c nx_tcp_server_socket_relisten.c nx_tcp_server_socket_unaccept.c nx_tcp_server_socket_unlisten.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_bytes_available.c nx_tcp_socket_connection_reset.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_disconnect_complete_notify.c nx_tcp_socket_driver_establish.c nx_tcp_socket_driver_packet_receive.c nx_tcp_socket_establish_notify.c nx_tcp_socket_info_get.c nx_tcp_socket_mss_get.c nx_tcp_socket_mss_peer_get.c nx_tcp_socket_mss_set.c nx_tcp_socket_packet_process.c nx_tcp_socket_peer_info_get.c nx_tcp_socket_queue_depth_notify_set.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_receive_queue_flush.c nx_tcp_socket_receive_queue_max_set.c nx_tcp_socket_retransmit.c nx_tcp_socket_send.c nx_tcp_socket_send_internal.c nx_tcp_socket_state_ack_check.c nx_tcp_socket_state_closing.c nx_tcp_socket_state_data_check.c nx_tcp_socket_state_established.c nx_tcp_socket_state_fin_wait1.c nx_tcp_socket_state_fin_wait2.c nx_tcp_socket_state_last_ack.c nx_tcp_socket_state_syn_received.c nx_tcp_socket_state_syn_sent.c nx_tcp_socket_state_transmit_check.c nx_tcp_socket_state_wait.c nx_tcp_socket_thread_resume.c nx_tcp_socket_thread_suspend.c nx_tcp_socket_timed_wait_callback.c nx_tcp_socket_transmit_configure.c nx_tcp_socket_transmit_queue_flush.c nx_tcp_socket_window_update_notify_set.c nx_tcp_transmit_cleanup.c nx_tcp_window_scaling_option_get.c nx_trace_event_insert.c nx_trace_event_update.c nx_trace_object_register.c nx_trace_object_unregister.c nx_udp_bind_cleanup.c nx_udp_enable.c nx_udp_free_port_find.c nx_udp_info_get.c nx_udp_packet_info_extract.c nx_udp_packet_receive.c nx_udp_receive_cleanup.c nx_udp_socket_bind.c nx_udp_socket_bytes_available.c nx_udp_socket_checksum_disable.c nx_udp_socket_checksum_enable.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_driver_packet_receive.c nx_udp_socket_info_get.c nx_udp_socket_port_get.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_source_send.c nx_udp_socket_unbind.c nx_udp_source_extract.c nx_utility.c nxd_icmp_enable.c nxd_icmp_ping.c nxd_icmp_source_ping.c nxd_icmpv6_ra_flag_callback_set.c nxd_ip_raw_packet_send.c nxd_ip_raw_packet_source_send.c nxd_ipv6_address_change_notify.c nxd_ipv6_address_delete.c nxd_ipv6_address_get.c nxd_ipv6_address_set.c nxd_ipv6_default_router_add.c nxd_ipv6_default_router_add_internal.c nxd_ipv6_default_router_delete.c nxd_ipv6_default_router_entry_get.c nxd_ipv6_default_router_get.c nxd_ipv6_default_router_number_of_entries_get.c nxd_ipv6_default_router_table_init.c nxd_ipv6_destination_table_find_next_hop.c nxd_ipv6_disable.c nxd_ipv6_enable.c nxd_ipv6_find_default_router_from_address.c nxd_ipv6_find_max_prefix_length.c nxd_ipv6_interface_find.c nxd_ipv6_multicast_interface_join.c nxd_ipv6_multicast_interface_leave.c nxd_ipv6_prefix_router_timer_tick.c nxd_ipv6_raw_packet_send_internal.c nxd_ipv6_router_lookup.c nxd_ipv6_router_solicitation_check.c nxd_ipv6_search_onlink.c nxd_ipv6_stateless_address_autoconfig_disable.c nxd_ipv6_stateless_address_autoconfig_enable.c nxd_nd_cache_entry_delete.c nxd_nd_cache_entry_set.c nxd_nd_cache_hardware_address_find.c nxd_nd_cache_invalidate.c nxd_nd_cache_ip_address_find.c nxd_tcp_client_socket_connect.c nxd_tcp_socket_peer_info_get.c nxd_udp_packet_info_extract.c nxd_udp_socket_send.c nxd_udp_socket_source_send.c nxd_udp_source_extract.c nxde_icmp_enable.c nxde_icmp_ping.c nxde_icmp_source_ping.c nxde_icmpv6_ra_flag_callback_set.c nxde_ip_raw_packet_send.c nxde_ip_raw_packet_source_send.c nxde_ipv6_address_change_notify.c nxde_ipv6_address_delete.c nxde_ipv6_address_get.c nxde_ipv6_address_set.c nxde_ipv6_default_router_add.c nxde_ipv6_default_router_delete.c nxde_ipv6_default_router_entry_get.c nxde_ipv6_default_router_get.c nxde_ipv6_default_router_number_of_entries_get.c nxde_ipv6_disable.c nxde_ipv6_enable.c nxde_ipv6_multicast_interface_join.c nxde_ipv6_multicast_interface_leave.c nxde_ipv6_stateless_address_autoconfig_disable.c nxde_ipv6_stateless_address_autoconfig_enable.c nxde_nd_cache_entry_delete.c nxde_nd_cache_entry_set.c nxde_nd_cache_hardware_address_find.c nxde_nd_cache_invalidate.c nxde_nd_cache_ip_address_find.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_packet_info_extract.c nxde_udp_socket_send.c nxde_udp_socket_source_send.c nxde_udp_source_extract.c nxe_arp_dynamic_entries_invalidate.c nxe_arp_dynamic_entry_set.c nxe_arp_enable.c nxe_arp_entry_delete.c nxe_arp_gratuitous_send.c nxe_arp_hardware_address_find.c nxe_arp_info_get.c nxe_arp_ip_address_find.c nxe_arp_static_entries_delete.c nxe_arp_static_entry_create.c nxe_arp_static_entry_delete.c nxe_icmp_enable.c nxe_icmp_info_get.c nxe_icmp_ping.c nxe_igmp_enable.c nxe_igmp_info_get.c nxe_igmp_loopback_disable.c nxe_igmp_loopback_enable.c nxe_igmp_multicast_interface_join.c nxe_igmp_multicast_interface_leave.c nxe_igmp_multicast_join.c nxe_igmp_multicast_leave.c nxe_ip_address_change_notify.c nxe_ip_address_get.c nxe_ip_address_set.c nxe_ip_auxiliary_packet_pool_set.c nxe_ip_create.c nxe_ip_delete.c nxe_ip_driver_direct_command.c nxe_ip_driver_interface_direct_command.c nxe_ip_forwarding_disable.c nxe_ip_forwarding_enable.c nxe_ip_fragment_disable.c nxe_ip_fragment_enable.c nxe_ip_gateway_address_clear.c nxe_ip_gateway_address_get.c nxe_ip_gateway_address_set.c nxe_ip_info_get.c nxe_ip_interface_address_get.c nxe_ip_interface_address_mapping_configure.c nxe_ip_interface_address_set.c nxe_ip_interface_attach.c nxe_ip_interface_capability_get.c nxe_ip_interface_capability_set.c nxe_ip_interface_detach.c nxe_ip_interface_info_get.c nxe_ip_interface_mtu_set.c nxe_ip_interface_physical_address_get.c nxe_ip_interface_physical_address_set.c nxe_ip_interface_status_check.c nxe_ip_link_status_change_notify_set.c nxe_ip_max_payload_size_find.c nxe_ip_raw_packet_disable.c nxe_ip_raw_packet_enable.c nxe_ip_raw_packet_filter_set.c nxe_ip_raw_packet_receive.c nxe_ip_raw_packet_send.c nxe_ip_raw_packet_source_send.c nxe_ip_raw_receive_queue_max_set.c nxe_ip_static_route_add.c nxe_ip_static_route_delete.c nxe_ip_status_check.c nxe_ipv4_multicast_interface_join.c nxe_ipv4_multicast_interface_leave.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_rarp_disable.c nxe_rarp_enable.c nxe_rarp_info_get.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_port_get.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_free_port_find.c nxe_tcp_info_get.c nxe_tcp_server_socket_accept.c nxe_tcp_server_socket_listen.c nxe_tcp_server_socket_relisten.c nxe_tcp_server_socket_unaccept.c nxe_tcp_server_socket_unlisten.c nxe_tcp_socket_bytes_available.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_disconnect_complete_notify.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_info_get.c nxe_tcp_socket_mss_get.c nxe_tcp_socket_mss_peer_get.c nxe_tcp_socket_mss_set.c nxe_tcp_socket_peer_info_get.c nxe_tcp_socket_queue_depth_notify_set.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_receive_queue_max_set.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_tcp_socket_timed_wait_callback.c nxe_tcp_socket_transmit_configure.c nxe_tcp_socket_window_update_notify_set.c nxe_udp_enable.c nxe_udp_free_port_find.c nxe_udp_info_get.c nxe_udp_packet_info_extract.c nxe_udp_socket_bind.c nxe_udp_socket_bytes_available.c nxe_udp_socket_checksum_disable.c nxe_udp_socket_checksum_enable.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_info_get.c nxe_udp_socket_port_get.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_source_send.c nxe_udp_socket_unbind.c nxe_udp_source_extract.c
  group Middlewares/ThreadX/common/src
    ../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Middlewares/ThreadX/ports/cortex_m33/ac6/src
    ../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group Misc/Cmd
    ../../../../Misc/Cmd/Src/: cmd.c
  group plf_config
    ../STM32_Cellular/Config/: plf_cellular_config.h plf_config.h plf_features.h plf_hw_config.h plf_ipc_config.h plf_power_config.h plf_rtosal_config.h plf_sw_config.h plf_thread_config.h
target Jenkins_Config (6140001::V6.14.1::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.1
  cpu: as above
  output: U585I_Jenkins_TCP_Echo_Client +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c misc: -Wno-format
  c include: as above
  asm define: TX_SINGLE_MODE_NON_SECURE=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
software components: CMSIS:CORE 5.4.0
